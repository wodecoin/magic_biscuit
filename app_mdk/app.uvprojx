# Keil uVision project app.uvprojx, settings and files
target app (6190000::V6.19::ARMCLANG)
  device: MM32F5277E7PV MindMotion
  pack: MindMotion.MM32F5277E_DFP.1.3.0
  cpu: IRAM(0x30000000,0x1C000) IROM(0x08000000,0x40000) CPUTYPE("Star-MC1") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: app +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,CUSTOM_HSE_VAL, USE_APP,LVGL_RTTHREAD
  c include: ..\mm32f5270_nano_frame\base\library\CMSIS\Core\Include;..\mm32f5270_nano_frame\base\library\MM32F5270\HAL_Lib\Inc;..\mm32f5270_nano_frame\base\library\MM32F5270\Include;..\mm32f5270_nano_frame\base\rtthread-nano-4.1.1\rt-thread\include;..\mm32f5270_nano_frame\base\rtthread-nano-4.1.1\rt-thread\libcpu\arm\cortex-m33;..\mm32f5270_nano_frame\base\rtthread-nano-4.1.1\rt-thread\components\finsh;..\mm32f5270_nano_frame\base\plat;..\mm32f5270_nano_frame\base\core;..\mm32f5270_nano_frame\base\3rd_party\lvgl_rtthread;..\mm32f5270_nano_frame\base\rtthread-nano-4.1.1\rt-thread\bsp\_template;..\user_app;..\user_app\ui\fonts;..\user_app\ui;..\user_app\ui\components;..\user_app\ui\screens;..\3rd_party\ulog;..\3rd_party\lvgl_rtthread
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x1c000
  scatter file: ..\mm32f5270_nano_frame\base\library\MM32F5270\Source\mm32f5270.sct
  group core
    ../mm32f5270_nano_frame/base/core/: main.c mm32f5270_it.c
  group task
    ../user_app/: app.c app_lvgl_port.c
  group dev
    ../mm32f5270_nano_frame/base/dev/: amoled_driver.c
  group ui
    ../user_app/ui/: ui.c ui_helpers.c
    ../user_app/ui/screens/: ui_Screen1.c
    ../user_app/ui/components/: ui_comp_hook.c
  group 3rd
    ../3rd_party/lvgl_rtthread/: lv_rt_thread_port.c lv_ui_entry.c
  group plat
    ../mm32f5270_nano_frame/base/plat/: mm32_adc.c mm32_gpio.c mm32_uart.c platform.c mm32_qspi.c mm32_soft_i2c.c
  group doc
    ../: README.md
  group HAL_LIB
    ../mm32f5270_nano_frame/base/library/MM32F5270/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_comp.c hal_cordic.c hal_crcpoly.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_enet.c hal_exti.c hal_flash.c hal_flexcan.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_lptim.c hal_lpuart.c hal_mds.c hal_misc.c hal_pwr.c hal_qspi.c hal_rcc.c hal_rtc.c hal_spi.c hal_syscfg.c hal_tim.c hal_uart.c hal_uid.c hal_usbfs.c hal_wwdg.c
  group STARTUP
    ../mm32f5270_nano_frame/base/library/MM32F5270/Source/: system_mm32f5270.c
    ../mm32f5270_nano_frame/base/library/MM32F5270/Source/KEIL_StartAsm/: startup_mm32f5270_keil.c
  group rtthread/src
    ../mm32f5270_nano_frame/base/rtthread-nano-4.1.1/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group rtthread/port
    ../mm32f5270_nano_frame/base/rtthread-nano-4.1.1/rt-thread/libcpu/arm/cortex-m33/: cpuport.c trustzone.c context_gcc.S
  group rtthread/board
    ../mm32f5270_nano_frame/base/rtthread-nano-4.1.1/rt-thread/bsp/_template/: board.c
  group rtthread/finsh
    ../mm32f5270_nano_frame/base/rtthread-nano-4.1.1/rt-thread/components/finsh/: cmd.c msh.c msh_file.c msh_parse.c shell.c
  group ulog
    ../3rd_party/ulog/: ulog.c
    ../3rd_party/ulog/backend/: console_be.c
software components: LVGL:lvgl:Essential 8.4.0, LVGL:lvgl:Extra Themes 8.4.0, LVGL:lvgl:Libs GIF 8.4.0, LVGL:lvgl:Libs PNG 8.4.0, LVGL:lvgl:Porting 8.4.0
